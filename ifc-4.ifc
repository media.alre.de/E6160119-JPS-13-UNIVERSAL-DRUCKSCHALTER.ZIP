Properties of the parts of a building model (IFC4)

# File
Description: Universal Druckschalter mit 2 Schaltbereichen. Mit 6-kant Anschluss-Stutzen SW17 mit 1/4" Innengewinde., ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6160119, Universal Druckschalter mit 2 Schaltbereichen. Mit 6-kant Anschluss-Stutzen SW17 mit 1/4" Innengewinde.
In: Raum
Description: Der JSP ist ein Universal-Druckschalter mit 2 Schaltbereichen, Starterknopf und Kontroll-Lampe sowie geeignet für Öl, Wasser und Luft. Er kann auch als Regler zur Steuerung und Überwachung in Hausölversorgungsanlagen, für Druckerhöhungsanlagen, Ölförderpumpen etc. verwendet werden.; Classification: EC000243 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6160119; ModelLabel: JPS-13; GlobalTradeItemNumber: 4050528031594; ProductURL: https://alre.de/produkt_E6160119
Pset_Specification - NominalLength: 0.086 m; NominalWidth: 0.075 m; NominalDepth: 0.05 m; NetWeight: 0.4
Pset_ALRE_ETIM_Properties - Breite: 75; Höhe: 86; Tiefe: 50; Anzahl der Hilfskontakte als Wechsler: 1; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP10; Elektronische Ausführung: no; Geeignet als Wächter: yes; Mediumtemperatur: -30; ETIM-Klasse: EC000243; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6160119.pdf
